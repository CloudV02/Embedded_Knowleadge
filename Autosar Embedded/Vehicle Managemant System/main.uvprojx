# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
